# IAR project clean_eyes.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003F3 STM8S003F3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S003
  ICCSTM8.CCIncludePath2: D:\STM8_CODE\clean_eyes\STM8S_StdPeriph_Driver\inc; D:\STM8_CODE\clean_eyes\APP; D:\STM8_CODE\clean_eyes\USER; D:\STM8_CODE\clean_eyes
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: clean_eyes.hex
  ILINK.IlinkOutputFile: clean_eyes.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group STM8S_StdPeriph_Driver
    STM8S_StdPeriph_Driver/src/: stm8s_gpio.c stm8s_tim2.c stm8s_tim4.c
  group USER
    USER/: main.c stm8s_it.c
